RUST_TARGETS_DIR = "${RECIPE_SYSROOT_NATIVE}/usr/lib/rustlib"
